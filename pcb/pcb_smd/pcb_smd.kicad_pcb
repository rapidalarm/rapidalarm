# Repository rapidalarm/rapidalarm

File README.md:

# Illinois RapidAlarm: Emergency ventilator sensor and alarm system

*Developed at the Grainger College of Engineering at the University of Illinois at Urbana-Champaign with support from Carle Health and Creative Thermal Solutions, Inc.*

The Illinois RapidAlarm is a sensor and alarm module for use with emergency pressure-cycled ventilators such as the [Illinois RapidVent](https://rapidvent.grainger.illinois.edu/). More information and documentation is available at the [Illinois RapidAlarm project website](http://rapidalarm.github.io).

2020 Copyright University of Illinois Board of Trustees. Software is licensed under the MIT License; all other designs and documentation are licensed under the CC BY 4.0 license: https://creativecommons.org/licenses/by/4.0/

Please see the [legal disclaimer](https://rapidalarm.github.io/#!legal.md) on the project website.

### Repository Structure

- `code/` - firmware for monitor ATMega, simulations
  - `data/` - labeled alarm test data from artificial lung
  - `firmware/` - ATmega328 alarm firmware
  - `rapidalarm/` - Python plotting tools and test suite
- `cad/` - mechanical CAD files, enclosures, etc.
    - `enclosure_lasercut/` - enclosure design files for lasercutter
    - `enclosure_3dprint/` - enclosure design files for 3d printer
- `pcb/` - KiCAD design files
  - `pcb_proto/` - through hole board variant, based on ATmega328
  - `pcb_smd/` - surface mount board variant, based on ATmega32u4

## KiCad design pcb/pcb_smd/pcb_smd.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_Murata_PKMCS0909E4000-R1
C1, C2, C4, C6, C7, C8, C9, C13: 1uF; C_0603_1608Metric
C3: 0.1uF; C_0603_1608Metric
C5: .01uF; C_0603_1608Metric
D1: D_Schottky; D_0603_1608Metric
D2, D3, D4, D5: D_Zener; D_0603_1608Metric
J1: USB_B_Micro; USB_Mini-B_Lumberg_2486_01_Horizontal
J2: AVR-ISP-6; ISP_POGO
J3: Conn_01x02; PinSocket_1x02_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
L1: 47nH; L_0603_1608Metric
R1: 10k; R_0603_1608Metric
R2, R3: 22; R_0603_1608Metric
R4: 2; R_0603_1608Metric
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R20: 470; R_0603_1608Metric
SW1, SW2, SW3: SW_Push; SW_Push_1P1T_NO_6x6mm_H9.5mm
U1: ATmega32U4-MU; TQFP-44_10x10mm_P0.8mm
U2: LTC-4627; LTC-4627_SMD
U3: MPXV5010; DIPSOP-8_W550thou
U5: LM4040DBZ-2.5; SOT-23
Y1: Resonator; Resonator_SMD_muRata_CSTxExxV-3Pin_3.0x1.1mm_HandSoldering

Connections:
+5V: C4.1, C5.1, D1.1 (K), D2.1 (K), J2.2 (VCC), L1.1, R1.1, R4.1, R20.1, U1.2, U1.7, U1.14, U1.34, U3.2 (Vs)
/AREF: C13.1, R20.2, U1.42, U5.1
/DIG1: U1.33, U2.1 (DIG1)
/DIG2: U1.18, U2.2 (DIG2)
/DIG3: U1.20, U2.6 (DIG3)
/DIG4: U1.22, U2.8 (DIG4)
/DIG:: U1.19, U2.4 (DIG:)
/DOWN: C7.1, D3.1 (K), R7.1
/DP: R15.1, U1.25
/MISO: J2.1 (MISO), U1.11
/MODE: C9.1, D5.1 (K), R5.1
/MOSI: J2.4 (MOSI), U1.10
/PRESSURE1: C6.1, R16.2, U1.41
/RST: J2.5 (~RST), R1.2, U1.13
/SCK: J2.3 (SCK), U1.9
/UP: C8.1, D4.1 (K), R6.1
/a: R8.1, U1.31
/b: R9.1, U1.32
/c: R10.1, U1.28
/d: R11.1, U1.29
/e: R12.1, U1.27
/f: R13.1, U1.26
/g: R14.1, U1.30
GND: BZ1.2 (+), C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C13.2, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), J1.5 (GND), J1.6 (Shield), J2.6 (GND), J3.2, J4.3, SW1.2, SW2.2, SW3.2, U1.5, U1.15, U1.23, U1.35, U1.43, U3.3 (GND), U5.2, Y1.2
unnamed: BZ1.1 (-), U1.12
unnamed: C1.2, U1.6
unnamed: C2.1, R4.2
unnamed: C3.1, L1.2, U1.24, U1.44
unnamed: D1.2 (A), J1.1 (VBUS)
unnamed: J1.2 (D-), R3.1
unnamed: J1.3 (D+), R2.1
unnamed: J3.1, U1.21
unnamed: J4.1, U1.37
unnamed: J4.2, U1.36
unnamed: R2.2, U1.4
unnamed: R3.2, U1.3
unnamed: R5.2, SW1.1
unnamed: R6.2, SW2.1
unnamed: R7.2, SW3.1
unnamed: R8.2, U2.14 (a)
unnamed: R9.2, U2.16 (b)
unnamed: R10.2, U2.12 (:), U2.13 (c)
unnamed: R11.2, U2.3 (d)
unnamed: R12.2, U2.5 (e)
unnamed: R13.2, U2.11 (f)
unnamed: R14.2, U2.15 (g)
unnamed: R15.2, U2.7 (DP)
unnamed: R16.1, U3.4 (Vout)
unnamed: U1.16, Y1.3
unnamed: U1.17, Y1.1

Notes on the sheet:
Programming Header
Extra
UART TX Debug
Button Input and Debouncing
Pressure Transducer and Filtering
Optional 2.5V Reference

Board: 2 copper layers, 53.3 x 47.0 mm, 46 parts (1 on the bottom side), 50 nets.

## KiCad design pcb/pcb_proto/pcb_proto.kicad_pcb

Board: 2 copper layers, 67.3 x 44.5 mm, 18 parts (1 on the bottom side), 31 nets.

Parts:
BZ1: Piezo; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C2, C4, C5: C; C_Disc_D5.0mm_W2.5mm_P2.50mm
ISP1: AVR-ISP-6; ISP_POGO
J1: Barrel_Jack; BarrelJack_Wuerth_6941xx301002
J3: CONSOLE; PinHeader_1x02_P2.54mm_Vertical
R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RN1, RN2: 680; R_Array_SIP6
SW1, SW2, SW3: SW_Push; SW_PUSH_6mm
U1: ATmega328P-PU; DIP-28_W7.62mm
U2: MPXV5010; DIPSOP-8_W550thou
U3: LTC-4627
Y1: Resonator_Small; Resonator_muRata_CSTLSxxxX-3Pin_W5.5mm_H3.0mm

Connections:
+5V: C1.1, C2.1, C4.1, ISP1.2, J1.1, R2.1, U1.7, U1.20, U2.2
/DIG1: RN1.4, U1.27
/DIG2: RN1.6, U1.25
/DIG3: ISP1.4, RN2.4, U1.17
/DIG4: RN2.6, U1.16
/DIG:: RN2.2, U1.23
/DP: U1.11, U3.7
/MISO: ISP1.1, U1.18, U3.16
/PRES: C5.1, RN1.2, U1.28
/RST: ISP1.5, R2.2, U1.1
/SCK: ISP1.3, U1.19
/a: U1.12, U3.14
/c: U1.13, U3.12, U3.13
/d: U1.24, U3.3
/e: U1.26, U3.5
/f: U1.14, U3.11
/g: U1.15, U3.15
GND: BZ1.2, C1.2, C2.2, C4.2, C5.2, ISP1.6, J1.2, J3.2, SW1.4, SW2.2, SW3.2, U1.8, U1.22, U2.3, Y1.2
unnamed: BZ1.1, U1.5
unnamed: J3.1, U1.3
unnamed: RN1.1, U2.4
unnamed: RN1.3, U3.1
unnamed: RN1.5, U3.2
unnamed: RN2.1, U3.4
unnamed: RN2.3, U3.6
unnamed: RN2.5, U3.8
unnamed: SW1.3, U1.2
unnamed: SW2.1, U1.4
unnamed: SW3.1, U1.6
unnamed: U1.9, Y1.3
unnamed: U1.10, Y1.1

## Commit log

2020-03-25 init commit
2020-03-26 add waveform simulations
2020-03-26 add plot
2020-03-26 switch to ramp excitation
2020-03-26 update model
2020-03-26 add esp bulk links
2020-03-27 add audio analysis
2020-03-27 update derivations
2020-03-30 update notes
2020-03-30 update diag
2020-03-30 update parts
2020-04-01 added data
2020-04-01 added readme
2020-04-01 clean data
2020-04-03 add code
2020-04-03 add debug printing
2020-04-07 update parts list
2020-04-07 fix table
2020-04-07 add new data
2020-04-07 update sample data
2020-04-07 add data descriptions
2020-04-07 add digikey cart share
2020-04-07 add design files
2020-04-07 better ground plane
2020-04-07 add prototype design
2020-04-07 remove gerbers zip
2020-04-07 update gerbers
2020-04-08 add display cod
2020-04-09 add alarm display
2020-04-13 add buttons
2020-04-14 update gitignore
2020-04-14 update through hole board
2020-04-14 purge old files
2020-04-14 organize code/
2020-04-14 more transducer options
2020-04-14 update readme repo structure
2020-04-14 move matlab into folder
2020-04-14 commit last working alarm code
2020-04-14 whitespace cleanup
2020-04-15 code separation, use floats
2020-04-15 move alarms to enums, add alarm.h, add rate alarms, alarm cancellation
2020-04-15 fix button map
2020-04-15 ad hi low rate alarm set mode
2020-04-15 move code into c file
2020-04-15 split files
2020-04-16 Updated pressure and rate tracking algorithm
2020-04-16 cleanup
2020-04-17 3d printable enclosure
2020-04-17 wider holes on pogo footprint
2020-04-17 more kicad ignores
2020-04-17 remove gerbers
2020-04-17 add schematic
2020-04-17 add schematic, remove gerbers
2020-04-17 ignore gerbers
2020-04-19 Create LICENSE
2020-04-19 Added project description, picture, copyright
2020-04-19 Move LICENSE to code folder
2020-04-20 Fixed so code compiles, matches documentation
2020-04-21 finish code split
2020-04-23 Tekmill Files
2020-04-24 update renders
2020-04-24 reorganize code
2020-04-24 remove pyc, move data
2020-04-24 ignore pyc files
2020-04-24 cleanup python package structure
2020-04-24 get working on windows
2020-04-24 add windows instructions
2020-04-24 button order
2020-04-24 add plotting function
2020-04-24 allow on the fly rebuilding
2020-04-25 update setup
2020-04-25 update instructions
2020-04-25 add image
2020-04-25 update data instructions, add ventmap2csv
2020-04-25 add more debug symbols to cdef
2020-04-25 trim bad data
2020-04-25 add converted data files
2020-05-11 dont symlink, pass sample_rate as arg
2020-05-22 convert to CMH2O
2020-05-22 use variable names given in paper
2020-05-22 clean up plotting, fix --rebuild
2020-05-22 switch pogo size
2020-05-22 overflow note
2020-05-22 debug plot
2020-05-30 add new ventmap data
2020-05-31 make true pip peep rr values accessible
2020-05-31 fix alg rebuild
2020-05-31 plot true pip peep
2020-06-01 add stat command, add true values to plot command
2020-06-19 finish smd version
2020-07-02 fix TX pin, fix VBUS
